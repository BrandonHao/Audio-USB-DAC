SRC_URI += "file://user_2019-12-11-08-53-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

